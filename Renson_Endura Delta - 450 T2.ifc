Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-13T12:06:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 13 12:06:51 2023 * Host: RENSON-PCuyzIdp * Database: C:\Users\naniw\AppData\Local\Temp\2d2cdb2f-2b05-4528-82d4-e2ef0707fead\b324db25-2cf1-4114-aea3-373e933d10cc\ifc * Database version: 5507 * Database creation date: Mon Mar 13 12:06:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 13 12:06:51 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 13 12:06:51 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (6)
Description: Flow
Name | FlowDirection
3 x Port_349076 | SINK
Port_349076 | SOURCEANDSINK
2 x Port_349076 | SOURCE

# IfcEnergyConversionDevice: 450 T2/B2, Renson_Endura Delta:450 T2/B2:349076
In: Level 1
Type - Material: Color RAL 9002, Color RGB 060-060-060, Color RGB 040-040-040
Pset_DistributionFlowElementCommon - Reference: 450 T2/B2; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_ProductRequirements - Category: Mechanical Equipment
